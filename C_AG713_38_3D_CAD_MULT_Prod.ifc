Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2025-04-04T09:46:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 04 09:46:11 2025 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{90F25DBB-A943-420E-8E63-AE2D3069980C}\ifc * Database version: 5507 * Database creation date: Fri Apr 04 09:46:11 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 04 09:46:11 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 04 09:46:11 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: D:\BIMCAD EU\ES-25031576 EU BIM drawings for AG703 and AG713\Working\3D Content\Normal Holes\AG713_38.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: AG713_38, AG713_38:AG713_38:86139
In: Level 1
Material: Galvanised
Pset_BuildingElementProxyCommon - Reference: AG713/38
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.0000624343 m3
Other - Category: Structural Connections; Family: AG713_38: AG713_38; Family and Type: AG713_38: AG713_38; Schedule Level: Level: Level 1; Type: AG713_38: AG713_38; Type Id: AG713_38: AG713_38; Family Name: AG713_38
Phasing - Phase Created: New Construction
General - Density: 0.48; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: AG713/38; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Copyright: ©Simpson Strong-Tie; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; Model: AG713/38; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0180523011167727987938686006252352135583; Name: AG713/38; ObjectType: AG713/38; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: AG713_38; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; URL: www.strongtie.eu
Materials and Finishes - Product Material: Galvanised
